# Repository ozw1z5rd/RAM2E

## KiCad design RAM2E.kicad_pcb

Board: 4 copper layers, 78.2 x 49.4 mm, 19 parts (0 on the bottom side), 3 nets.

Parts:
FID1, FID2, FID3, FID4: Fiducial
H1, H2, H4, H4#2, H4#3: PasteHole_1.1mm_PTH
J1: AppleIIeAux; AppleIIeAux_Edge
U1: TQFP-100_14x14mm_P0.5mm
U2: TSOP-II-54_22.2x10.16mm_P0.8mm
U3, U4, U5, U6, U7: TSSOP-20_4.4x6.5mm_P0.65mm
U8, U9: SOT-223-6

Connections:
+5V: J1.30, U6.20, U7.20, U8.1, U8.5, U9.1, U9.5
/AN3: J1.50, J1.55
GND: H1.1, H2.1, H4.1, H4#2.1, H4#3.1, J1.31, U1.10, U1.11, U1.32, U1.46, U1.60, U1.65, U1.79, U1.93, U2.6, U2.12, U2.28, U2.41, U2.46, U2.52, U2.54, U3.10, U3.19, U4.10, U4.19, U5.10, U5.19, U6.1, U6.10, U7.1, U7.10, U8.3, U8.6, U9.3, U9.6

## KiCad design ramiie.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8: 100n; C_0805
FID1, FID2, FID3, FID4: Fiducial
H1, H2, H3, H4: PasteHole_1.1mm_PTH
J1: AppleIIeAux; AppleIIeAux_Edge
U1: EPM7128SL84; PLCC-84
U2: 2M x 8; SOJ-28-300mil

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, J1.30, U1.3, U1.13, U1.26, U1.38, U1.43, U1.53, U1.66, U1.78, U2.1, U2.14
/3.58M: J1.1, U1.10
/7M: J1.59, U1.9
/14M: J1.32, U1.83, U1.84
/AN3: J1.50, J1.55, U1.4
/GR: J1.58
/H0: J1.47
/MD0: J1.44, U1.57
/MD1: J1.43, U1.61
/MD2: J1.40, U1.68
/MD3: J1.39, U1.73
/MD4: J1.21, U1.69
/MD5: J1.20, U1.65
/MD6: J1.17, U1.58
/MD7: J1.16, U1.55
/PHI0: J1.23, U1.75
/PHI1: J1.36, U1.79
/Q3: J1.53, U1.1, U1.2
/RA0: J1.51, U1.45, U2.10
/RA1: J1.10, U1.46, U2.18
/RA2: J1.49, U1.48, U2.11
/RA3: J1.48, U1.49, U2.17
/RA4: J1.13, U1.50, U2.12
/RA5: J1.14, U1.51, U2.16
/RA6: J1.46, U1.52, U2.13
/RA7: J1.9, U1.44, U2.19
/RA8: U1.41, U2.20
/RA9: U1.40, U2.21
/RA10: U1.24, U2.9
/RA11: U1.25, U2.8
/RD0: U1.33, U2.2
/RD1: U1.34, U2.3
/RD2: U1.35, U2.4
/RD3: U1.36, U2.5
/RD4: U1.28, U2.24
/RD5: U1.29, U2.25
/RD6: U1.30, U2.26
/RD7: U1.31, U2.27
/ROMEN1: J1.11
/ROMEN2: J1.12
/R~WE~: U1.37, U2.6
/R~W~: J1.52, U1.5
/R~W~80: J1.35, U1.80
/SEGA: J1.8
/SEGB: J1.54
/V0: J1.45, U1.56
/V1: J1.42, U1.63
/V2: J1.41, U1.67
/V3: J1.38, U1.74
/V4: J1.22, U1.70
/V5: J1.19, U1.64
/V6: J1.18, U1.60
/V7: J1.15, U1.54
/VC: J1.5
/Vid7M: J1.2
/~80VID~: J1.25
/~ALTVID~: J1.27
/~C07X~: J1.6, U1.6
/~CASEN~: J1.37, U1.77
/~CAS~: U1.27, U2.23
/~CLRGAT~: J1.24
/~EN80~: J1.26, U1.76
/~ENTMG~: J1.60
/~ENVID~: J1.29
/~LDPS~: J1.34
/~PCAS~: J1.33, U1.81
/~PRAS~: J1.4, U1.8
/~RA9~: J1.56
/~RA10~: J1.57
/~RAS~: U1.39, U2.7
/~SEROUT~: J1.28
/~SYNC~: J1.3
/~WNDW~: J1.7
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, H1.1, H2.1, H3.1, H4.1, J1.31, U1.7, U1.19, U1.32, U1.42, U1.47, U1.59, U1.72, U1.82, U2.15, U2.22, U2.28
unnamed: U1.12, U1.15
unnamed: U1.16, U1.17
unnamed: U1.18, U1.20
unnamed: U1.21, U1.22

Notes on the sheet:
C14M
PHI0
10011
11011
10111
01111
00011
01011
00001
01000
00000
01100
C7M
11001
10000
11000
10100
6502 CPU Access
Video Access
nRAS
nCAS
HoldRow
nRefRAS
GateWE
GateCRAS
nPCAS
nPRAS
nRefCAS
nRAS <= GateCRAS ? nRefRAS : nPRAS nCAS <= GateCRAS ? nRefCAS : Q3 nRWE <= GateWE | RW80 RA[7:0] <= HoldRow ? RowAddr[7:0] : MA[7:0] RA[10:8] <= PHI1 ? 0 : HoldRow ? BA[5:3] : BA[2:0] RA[11] <= PHI1 ? 0 : BA[5]
VDR[7:0] <= RD[7:0] @ PHI0 VD[7:0] <= PHI1 ? 8’bZ : VDR[7:0] D[7:0] <= (EN80 & R~W~80) ? RD[7:0] : 8’bZ RD[7:0] <= (EN80 & ~R~W80) ? D[7:0] : 8’bZ
GateCRAS <= state == 10100 | 01111 | 00011 | 01011 @ C14M nRefRAS <= ~state == 01111 | 01011 | 00001~ @ C14M nRefCAS <= ~state == 01111 | 00011~ @ ~C14M~ GateWE <= state == 10100 | 00011 @ C14M HoldRow <= state == 01011 | 10011 @ ~C14M~ RowAddr[7:0] <= MA[7:0] @ ~nPRAS~ BA[5:0] <= D[5:0] @ C14M in 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

Board: 4 copper layers, 77.7 x 53.0 mm, 19 parts (0 on the bottom side), 59 nets.

## Commit log

2019-06-09 Done some
2019-06-10 did a lot
2019-06-25 I think it's done
2019-06-26 Changed name to "RAM2E"
2019-07-30 halfway done widening clearances
2019-07-30 Finished new revision 0.6
    Wider clearance and 1 more bypass cap
2019-08-01 New CPLD idea
    Also changed to 1k2R + 10pF RC delay
2019-10-14 CPLD design prototype
2019-10-14 Added note about Delay0
2019-10-14 Schematic documentation update
2019-10-14 quartus crap
2019-10-18 PLD: Delay EN80 like on Apple extended 80-column board
2019-11-18 Start redoing state...
2019-11-18 Changed to state counter
2019-11-21 Removed mux dependency on PCAS
2019-12-08 Release candidate
2019-12-21 New delay stuff... is it good?
2020-02-05 Limited to 1MB
2020-02-16 Bank select register at $C071, $C073, $C075, $C077
2020-02-17 Timing fixes
2020-02-17 Bank register set at end of S11, memory data bus active S11-S15
2020-03-17 Added instructions
2020-03-21 more
2020-04-27 Sent to JLCPCB
2020-04-27 Fixed board GW number silkscreen, added config jumpers
2020-05-02 CPLD fixes
2020-05-06 Added *.sch-bak to gitignore
2020-05-06 Added jumper, new state machine docs
2020-05-06 New state machine
2020-05-06 Documentation
2020-05-06 Tuned timing assignment stuff
2020-05-18 As sent to JLCPCB May 2020
2020-05-22 Added capacity selection
2020-05-30 Added label images
2020-05-31 Gonna try this
2020-05-31 Works!
2020-05-31 Made default RWMask be 0x7F for only 8MB
2020-06-01 Release candidate 1
2020-06-01 Removed pof files examine from RAM2Es
2020-06-01 Changed ZeroRWBank to SetRWBankFF
2020-06-02 Release candidate 2
2020-07-06 Create Description
2020-07-21 Renamed documentation files
2020-07-25 Documentation update
